# Repository XuHg-zjcn/bicycle_board

File README.md:

# 自行车主控板

## 前系统特征
### 板载资源
- ESP32-C3-WROOM-2U, xx32F103C8T6
- 太阳能Buck降压电路，可用MPPT驱动
- USB 5V输出升压电路(PS7516)
- USB充电电路(TP4056)
- 数字功放(NS4168)
- 2路NMOS(可连接车灯、报警器)
- IMU传感器(QMI8610,ICM-42688-P)
- 磁力计(QMC6308,QMC7983)
- 气压计(SPL06-001)
- 温湿度计(AHT20)
- FRAM储存器(MB85RS256B)

### 接口
- 8PIN SPI显示屏接口
- 扬声器接口
- I2S麦克风
- TF卡槽
- 3.7V锂电池接口
- 外置I2C接口(连接传感器和GPIO扩展芯片)
- 指纹传感器接口
- 后系统接口(UART)
- USB-C口(可充电,连接ESP32-C3模块)
- USB-A口(可放电,连接xx32芯片)
- 5V输出接口，用于连接USB公头
- 霍尔传感器接口x2(2个可以用于区分前进和后退)

### 待添加
- USB PD输出
- 外置电池组接口
- 转向角编码器接口
- 板载LoRa模块
- 发电机稳压电路

## 评论
前系统有一些射频发射源，GNSS模块和天线打算放在后系统附近，通过增大距离来减少干扰。  
暂时不考虑刷卡解锁，先考虑支持指纹和蓝牙  
按键，刹车开关，副车灯，风扇等电路等放在与显示屏同一块PCB中，使用PCA9555/TCA9555 GPIO扩展芯片  
为了提高稳定性，IMU和磁力计PCB上各有两个的不同封装可以焊接，只焊一个也可以。

为了减少git仓库占用空间，我在`git commit`提交前在KiCad中清除所有填充域(快捷键Ctrl+B)，您可以在打开后重新填充(快捷键B)  
在KiCad的Python控制台中，切换到该repo根目录运行下例命令
````python
import build
build.all()
```
即可自动完成添加泪滴、重新填充、应用PCB背面信息字符串

## 历史
2024.12.23 发布v1.0(第一次PCB打样)

下一个版本考虑
- 把ESP32和外围设备(microSD、音频等)等移动到显示屏附近PCB上
- 是否应该将太阳能、发电机相关电路尽可能移动到太阳能板、发电机附近

2025.2.21 发现TXB0108PW的OE端未连接，已飞线连接到+1V8

2025.3.21 发现用于光伏MPPT的DCDC不可用，Q6栅极关闭时电流会从体二极管流过

## 版权和许可证
Copyright (C) 2024 徐瑞骏

本设计以CERN开放硬件许可证第二版强互惠授权(CERN Open Hardware Licence Version 2 - Strongly Reciprocal)，许可证文件位于`LICENSE.txt`

本设计不提供任何保证

## KiCad design bicycle_board.kicad_pcb

Parts:
C13, C26, C27, C28, C29, C30, C32, C42: 100nF; C_0402_1005Metric
C14: 2.2uf; C_0603_1608Metric
C16: 100u; C_1210_3225Metric
C22, C23, C24, C25: C_Small; C_0402_1005Metric
C36, C37: 1nF; C_0402_1005Metric
C38: 1uF; C_0402_1005Metric
C39: 100uF; C_1210_3225Metric
C48: 100n; C_0402_1005Metric
C51, C54, C55, C56, C61: 0.1u; C_0402_1005Metric
C52: 10nf; C_0402_1005Metric
C53: 2.2u; C_0603_1608Metric
D1, D2, D8, D9, D10, D11, D12, D13, D14, D15, D16: ESD5Zxx; D_SOD-523
FB1, FB2: 1000; L_0805_2012Metric
J1: Micro_SD_Card; microSD_Slot_mybuy
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J5: Conn_01x08; JST_SH_SM08B-SRSS-TB_1x08-1MP_P1.00mm_Horizontal
J6, J11: Conn_01x04; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J7: Conn_01x05; JST_SH_SM05B-SRSS-TB_1x05-1MP_P1.00mm_Horizontal
J8: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J9: Conn_01x06; JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal
J10: USB_A; USB_A_Molex_67643_Horizontal
J12, J14: Conn_01x01; TestPoint_Pad_D1.0mm
J13: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
NT1: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q1, Q4: Q_NMOS_GSD; SOT-23
Q9: Q_PMOS_GSD; SOT-523
R1, R5: R_Small; R_0402_1005Metric
R2, R9: 470; R_0402_1005Metric
R4: 4.7; R_0402_1005Metric
R6, R7: 10k; R_0402_1005Metric
R27, R28, R30, R31: 47k; R_0402_1005Metric
U7: 74HC595; SSOP-16_4.4x5.2mm_P0.65mm
U10, U18: USBLC6-2SC6; SOT-23-6
U13: NS4168; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm
U14: ESP32-C3-WROOM-02U
U15: CH32V203C8T6; LQFP-48_7x7mm_P0.5mm
U20: MB85RS256B; SSOP-8_3.9x5.05mm_P1.27mm
Y1: 12MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm
Y2: 32.768kHz; Crystal_SMD_2012-2Pin_2.0x1.2mm

Connections:
+3.3V: C13.1, C14.1, C16.1, C26.1, C27.1, C28.1, C29.1, C30.1, C32.1, C42.2, C51.1, C54.2, C55.1, C56.2, C61.2, J1.4 (VDD), J5.7, J6.4, J7.5, J9.1, J9.3, Q9.2 (S), R6.1, R27.1, R28.1, R30.1, R31.1, U7.16 (VCC), U14.1 (3V3), U14.2 (EN), U15.1 (VBAT), U15.9 (VDDA), U15.24 (VDD), U15.36 (VDD), U15.48 (VDD), U20.3 (~WP), U20.7 (~HOLD), U20.8 (VDD); also elsewhere on the board
+5V: J10.1 (VBUS), U18.5 (VBUS); also elsewhere on the board
+BATT: C38.1, C39.1, C53.2, J13.1, U13.6 (VDD); also elsewhere on the board
/5VOUT_EN: U15.25 (PB12); also elsewhere on the board
/595_CLR: U7.10 (~SRCLR), U14.18 (IO0)
/595_RCLK: U7.12 (RCLK), U14.3 (IO4)
/ADC_Isolar: U15.14 (PA4); also elsewhere on the board
/ADC_Vbat: U15.15 (PA5); also elsewhere on the board
/ADC_Vsolar: U15.16 (PA6); also elsewhere on the board
/CH1: R2.1, U15.18 (PB0)
/CH2: R9.1, U15.19 (PB1)
/GND_audio: C36.2, C37.2, C38.2, C39.2, NT1.2, U13.7 (GND)
/HALL1: D13.1 (K), J11.3, U15.10 (PA0)
/HALL2: D9.1 (K), J11.4, U15.11 (PA1)
/HALL_EN: Q9.1 (G), U15.17 (PA7)
/I2SI_BCK: D15.1 (K), J7.2, U14.10 (IO10)
/I2SI_SD: D14.1 (K), J7.1, U14.15 (IO3)
/I2SI_WS: D16.1 (K), J7.3, U14.17 (IO1)
/I2SO_BCK: U13.3 (BCLK), U14.4 (IO5)
/I2SO_SD: U13.4 (SDATA), U14.7 (IO8)
/I2SO_WS: R6.2, U13.2 (LRCLK), U14.8 (IO9)
/LCD_BL: J5.1, U7.1 (QB)
/LCD_DC: J5.4, U7.4 (QE)
/LCD_RST: J5.3, U7.3 (QD)
/PWM_solar: U15.26 (PB13); also elsewhere on the board
/PWM_solarL: U15.29 (PA8); also elsewhere on the board
/QMI_INT1_3V3: U15.37 (PA14); also elsewhere on the board
/RXD: D12.1 (K), J13.3, U14.11 (IO20/RXD), U15.31 (PA10)
/SCL1: U15.45 (PB8); also elsewhere on the board
/SCL2: D2.1 (K), J6.2, U15.21 (PB10)
/SDA1: U15.46 (PB9); also elsewhere on the board
/SDA2: D10.1 (K), J6.1, U15.22 (PB11)
/SPISen_CS_FRAM: U15.34 (PA13), U20.1 (~CS)
/SPISen_CS_QMI_3V3: U15.38 (PA15); also elsewhere on the board
/SPISen_CS_TDK_3V3: U15.42 (PB6); also elsewhere on the board
/SPISen_MISO_3V3: U15.40 (PB4), U20.2 (SO); also elsewhere on the board
/SPISen_MOSI_3V3: U15.41 (PB5), U20.5 (SI); also elsewhere on the board
/SPISen_SCLK_3V3: U15.39 (PB3), U20.6 (SCK); also elsewhere on the board
/SPI_CS_LCD: J5.2, U7.2 (QC)
/SPI_CS_SD: J1.2 (DAT3/CD), R27.2, U7.15 (QA)
/SPI_MISO: J1.7 (DAT0), R31.2, U14.16 (IO2)
/SPI_MOSI: J1.3 (CMD), J5.5, R28.2, U7.14 (SER), U14.6 (IO7)
/SPI_SCLK: J1.5 (CLK), J5.6, R30.2, U7.11 (SRCLK), U14.5 (IO6)
/SPK_EN: U7.7 (QH), U13.1 (CTRL)
/TDK_INT2_3V3: U15.43 (PB7); also elsewhere on the board
/TXD: D1.1 (K), J13.4, U14.12 (IO21/TXD), U15.30 (PA9)
/USB_CH32FS_D+: U15.33 (PA12), U18.3 (I/O2)
/USB_CH32FS_D-: U15.32 (PA11), U18.1 (I/O1)
/USB_ESP_D+: U10.4 (I/O2), U14.14 (IO19)
/USB_ESP_D-: U10.6 (I/O1), U14.13 (IO18)
/ZW101_RX: D8.1 (K), J9.5, U15.12 (PA2)
/ZW101_TX: D11.1 (K), J9.4, U15.13 (PA3)
/batsamp_en: U15.27 (PB14); also elsewhere on the board
/power/VUSB: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U10.5 (VBUS); also elsewhere on the board
GND: C13.2, C14.2, C16.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C32.2, C42.1, C48.1, C51.2, C52.2, C53.1, C54.1, C55.2, C56.1, C61.1, D1.2 (A), D2.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), J1.6 (VSS), J1.10 (SHIELD), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J5.8, J5.MP (MountPin), J6.3, J6.MP (MountPin), J7.4, J7.MP (MountPin), J9.6, J9.MP (MountPin), J10.4 (GND), J10.5 (Shield), J11.2, J11.MP (MountPin), J13.2, NT1.1, Q1.2 (S), Q4.2 (S), R1.2, R5.2, R7.1, U7.8 (GND), U7.13 (~OE), U10.2 (GND), U13.9 (EP), U14.9 (GND), U14.19 (GND), U15.8 (VSSA), U15.23 (VSS), U15.35 (VSS), U15.47 (VSS), U18.2 (GND), U20.4 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: J2.A6 (D+), J2.B6 (D+), U10.3 (I/O2)
unnamed: J2.A7 (D-), J2.B7 (D-), U10.1 (I/O1)
unnamed: C36.1, FB1.2, J8.1
unnamed: C37.1, FB2.2, J8.2
unnamed: J10.3 (D+), U18.4 (I/O2)
unnamed: J10.2 (D-), U18.6 (I/O1)
unnamed: C52.1, J11.1, R4.2
unnamed: J12.1, Q1.3 (D)
unnamed: J14.1, Q4.3 (D)
unnamed: Q1.1 (G), R1.1, R2.2
unnamed: Q4.1 (G), R5.1, R9.2
unnamed: Q9.3 (D), R4.1
unnamed: FB2.1, U13.8 (VoN)
unnamed: FB1.1, U13.5 (VoP)
unnamed: R7.2, U15.44 (BOOT0)
unnamed: C48.2, U15.7 (NRST)
unnamed: C22.1, U15.3 (PC14), Y2.1
unnamed: C23.1, U15.4 (PC15), Y2.2
unnamed: C25.1, U15.5 (PD0), Y1.3
unnamed: C24.1, U15.6 (PD1), Y1.1

Notes on the sheet:
ESP32C6只能作为SDIO从机，无法驱动SD卡
GPIO2,8,9与启动模式有关
1.8V信号输入 需接到FT IO
应该加短路保护
TF卡槽处已上拉

Parts:
C9, C19, C35: 0.1uf; C_0402_1005Metric
C10: 10nF; C_0402_1005Metric
C11, C12, C17, C18, C20, C21, C60: 100nF; C_0402_1005Metric
C15: 2.2uF; C_0402_1005Metric
C33: 2.2uf; C_0603_1608Metric
C34: 10uf; C_0603_1608Metric
C59: 4.7uF; C_0603_1608Metric
R23, R25, R26: R; R_0402_1005Metric
R24: 1k; R_0402_1005Metric
R32: 330; R_0603_1608Metric
R35: 200k; R_0402_1005Metric
U3: ICM-42688-P; Bosch_LGA-14_3x2.5mm_P0.5mm
U4: QMI8610; LGA-16_3x3mm_P0.5mm
U5: AHT20; DFN-6_3x3mm_P1.0mm_AHT2x_AHT30
U9: PCA9306DC1; VSSOP-8_2.3x2mm_P0.5mm
U11: BMP280; Bosch_LGA-8_2x2.5mm_P0.65mm_ClockwisePinNumbering
U12: QMC6308; WLP-4_0.86x0.86mm_P0.4mm
U17: TXB0108PW; TSSOP-20_4.4x6.5mm_P0.65mm
U19: QMC7983; WLP-8_1.2x1.2mm_Layout3x3_P0.4mm_Pad0.24mm

Connections:
+1V8: C9.2, C10.2, C12.2, C15.2, C17.2, C19.2, C20.2, C33.2, C35.2, C60.1, R23.1, R24.1, U3.5 (VDDIO), U3.8 (VDD), U4.8 (VDDd), U9.2 (VREF1), U11.2 (CSB), U11.6 (VDDIO), U11.8 (VDD), U12.B1 (VDD), U17.2 (V_{CCA}), U19.C1 (DVDD); also elsewhere on the board
+3.3V: C11.2, C21.2, C59.1, R25.1, R26.1, R32.1, R35.1, U4.2 (VDDa), U17.19 (V_{CCB}), U19.A1 (AVDD), U19.A2 (ADDR); also elsewhere on the board
/QMI_INT1_3V3: U17.18 (B2); also elsewhere on the board
/SCL1: R25.2, U5.3 (SCL), U9.6 (SCL2); also elsewhere on the board
/SDA1: R26.2, U5.4 (SDA), U9.5 (SDA2); also elsewhere on the board
/SPISen_CS_QMI_3V3: U17.17 (B3); also elsewhere on the board
/SPISen_CS_TDK_3V3: U17.13 (B7); also elsewhere on the board
/SPISen_MISO_3V3: U17.15 (B5); also elsewhere on the board
/SPISen_MOSI_3V3: U17.14 (B6); also elsewhere on the board
/SPISen_SCLK_3V3: U17.16 (B4); also elsewhere on the board
/TDK_INT2_3V3: U17.12 (B8); also elsewhere on the board
/sensors/QMI_INT1: U4.12 (INT1), U17.3 (A2)
/sensors/QMI_INT2: U4.11 (INT2)
/sensors/SCL1V8: R23.2, U9.3 (SCL1), U11.4 (SCK), U12.A2 (SCL), U19.B3 (SCL)
/sensors/SDA1V8: R24.2, U9.4 (SDA1), U11.3 (SDI), U12.B2 (SDA), U19.C3 (SDA)
/sensors/SPISen_CS_QMI_1V8: U4.10 (CS), U17.4 (A3)
/sensors/SPISen_CS_TDK_1V8: U3.12 (AP_CS), U17.8 (A7)
/sensors/SPISen_MISO_1V8: U3.1 (AP_SDO/AP_AD0), U4.9 (SA0), U17.6 (A5)
/sensors/SPISen_MOSI_1V8: U3.14 (AP_SDA/AP_SDIO/AP_SDI), U4.13 (SDA), U17.7 (A6)
/sensors/SPISen_SCLK_1V8: U3.13 (AP_SCL/AP_SCLK), U4.14 (SCL), U17.5 (A4)
/sensors/TDK_INT1: U3.4 (INT1/INT)
/sensors/TDK_INT2_1V8: U3.9 (INT2/FSYNC/CLKIN), U17.9 (A8)
GND: C9.1, C10.1, C11.1, C12.1, C15.1, C17.1, C18.1, C19.1, C20.1, C21.1, C33.1, C34.2, C35.1, C59.2, C60.2, U3.6 (GND), U3.7 (GND), U4.3 (GNDa), U4.15 (GNDd), U5.5 (GND), U9.1 (GND), U11.1 (GND), U11.7 (GND), U12.A1 (VSA), U17.11 (GND), U19.B1 (GND); also elsewhere on the board
unnamed: C34.1, R32.2, U5.2 (VDD)
unnamed: C18.2, R35.2, U9.7 (VREF2), U9.8 (EN)

Parts:
C1, C3, C4, C5, C7, C8: 2.2u; C_0805_2012Metric
C2, C6, C40, C41: 100u; C_1210_3225Metric
C31: 10nF; C_0402_1005Metric
C43, C49: 2.2u; C_0603_1608Metric
C44: 10uF; C_0805_2012Metric
C45: C_Small; C_0402_1005Metric
C46: 47uf; C_1210_3225Metric
C47: 0.1uf; C_0402_1005Metric
C50, C57: 1uf; C_0603_1608Metric
C58: 0.1u; C_0402_1005Metric
D3: D_Schottky; D_SOD-123F
D4: D_Zener; D_SOD-123F
D5: Blue; LED_0603_1608Metric
D6: Red; LED_0603_1608Metric
D7: D; D_SOD-323
J3, J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
L1, L3: L; L_6.3x6.3_H3
NT2: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q6, Q7: Si2302; SOT-23
Q8: Q_PMOS_GSD; SOT-23
R3: 0.4; R_1206_3216Metric
R11: 220k; R_0402_1005Metric
R12: 0.01; R_1206_3216Metric
R13: 1200; R_0402_1005Metric
R14, R16: 47k; R_0402_1005Metric
R15: 100k; R_0402_1005Metric
R17: 33k; R_0402_1005Metric
R18, R19, R20, R21: R; R_0402_1005Metric
R22: 1k; R_0402_1005Metric
R29: 330k; R_0402_1005Metric
R33, R34: R_Small; R_0402_1005Metric
U1: TP4056; HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.4x3.2mm_ThermalVias
U2: SGM2039; DFN-8-1EP_1.2x1.6mm_P0.4mm_EP0.3x1.3mm
U6: SGM2033-1.8; SOT-23-5
U8: SGM8040-1; SOT-23-5
U16: PS7516; SOT-23-6

Connections:
+1V8: C7.1, U6.5 (OUT); also elsewhere on the board
+3.3V: C8.1, C43.1, C49.1, C58.1, U2.1 (OUT), U2.2 (OUT), U2.4 (FB), U8.5 (V+); also elsewhere on the board
+5V: C46.1, C47.1, R33.1, U16.5 (V_{OUT}); also elsewhere on the board
+BATT: C3.1, C4.1, C5.1, C6.1, C41.1, C44.1, C45.1, C57.1, D4.1 (K), J4.1, L1.1, L3.2, Q8.2 (S), U1.5 (BAT), U2.6 (EN), U2.7 (IN), U2.8 (IN), U6.1 (IN), U6.3 (EN), U16.6 (V_{IN}); also elsewhere on the board
/5VOUT_EN: U16.4 (EN); also elsewhere on the board
/ADC_Isolar: R20.2, U8.1; also elsewhere on the board
/ADC_Vbat: R14.2, R15.1; also elsewhere on the board
/ADC_Vsolar: R16.2, R17.1; also elsewhere on the board
/PWM_solar: Q6.1 (G), R11.2; also elsewhere on the board
/PWM_solarL: Q7.1 (G), R29.1; also elsewhere on the board
/batsamp_en: Q8.1 (G); also elsewhere on the board
/power/VUSB: R3.1; also elsewhere on the board
GND: C3.2, C4.2, C7.2, C8.2, C43.2, C44.2, C45.2, C46.2, C47.2, C49.2, C50.2, C57.2, C58.2, D4.2 (A), J4.2, NT2.2, R12.2, R13.2, R15.2, R21.1, R34.2, U1.1 (TEMP), U1.3 (GND), U1.9 (E), U2.5 (GND), U2.9 (EP), U6.2 (GND), U8.2 (V-), U16.2 (GND); also elsewhere on the board
unnamed: C5.2, C6.2, C31.2, C41.2, D3.2 (A), Q6.2 (S), Q7.2 (S), R12.1, R17.2, R19.1, R29.2
unnamed: C1.1, C2.1, C40.1, D3.1 (K), D7.2 (A), J3.1, L3.1, Q7.3 (D), R11.1
unnamed: D5.2 (A), D6.2 (A), R22.2
unnamed: D5.1 (K), U1.6 (STDBY)
unnamed: D6.1 (K), U1.7 (CHRG)
unnamed: C31.1, D7.1 (K), R16.1
unnamed: C1.2, C2.2, C40.2, J3.2, Q6.3 (D)
unnamed: NT2.1, R18.1
unnamed: Q8.3 (D), R14.1
unnamed: C50.1, R3.2, R22.1, U1.4 (Vcc), U1.8 (CE)
unnamed: R13.1, U1.2 (PROG)
unnamed: R18.2, R21.2, U8.3 (+)
unnamed: R19.2, R20.1, U8.4 (-)
unnamed: L1.2, U16.1 (SW)
unnamed: R33.2, R34.1, U16.3 (V_{FB})

Board: 2 copper layers, 40.9 x 84.4 mm, 158 parts (47 on the bottom side), 102 nets.

## Commit log

2024-11-18 MOS管修改为GSD, 添加芯片附近滤波电容、上拉电阻等，调整模块间布局，改正AHT20封装，电解电容替换成1210 MLCC
2024-11-18 添加升压USB 5V输出
2024-11-18 PCB上元器件分组
2024-11-18 初步划定PCB边缘，改为紧凑布局
2024-11-19 收窄PCB宽度到47.4mm
2024-11-19 画我现有的SD卡槽封装，应用到PCB
2024-11-20 PCB宽度进一步收缩到41.4mm，晶振改2016和2012，最小线距改0.15mm，添加一些布线
2024-11-22 添加CERN-OHL-S许可证、README.md文件
2024-12-01 连接大多数布线，做一些调整，添加覆铜
2024-12-01 移除第二个74HC595，SGM2033-1.8改成一直开启，按PCA9306数据手册修改供电
2024-12-01 修改小孔径为0.25/0.5mm
2024-12-01 修复一些DRC错误和警告，大多数信号接口改成SH1.0接口
2024-12-04 添加霍尔元件接口，移除CH2,CH3 MOS通道，调整和连接布线，取消STM32与ESP32的SPI连接
2024-12-05 调整STM32 GPIO使用，移除右侧MOS通道，只在左侧底部保留2个，计划采用PCA9555/TCA9555 GPIO扩展芯片
2024-12-05 连接ESP32和I2S麦克风接口
2024-12-05 调整电源线宽度，一些走线布局
2024-12-09 接口添加TVS二极管和去耦电容，调整已有电容连接走线宽度
2024-12-09 I2S麦克风接口添加TVS管
2024-12-09 添加3个机械孔
2024-12-11 微调元器件布局和走线，适当增大TXD与RXD，SCL1与SDA1走线间距
2024-12-11 整理分组：添加缺失的成员，新建一些分组，给分组命名
2024-12-12 修复和排除一些DRC错误
2024-12-12 整理和添加一些接口丝印和背面信息文本
2024-12-13 改进电源走线，添加小面积覆铜；添加USB-A接口背面MOS管位号
2024-12-13 移动和微调MOS管通道电路并添加外接电路焊盘
2024-12-13 更新README.md
2024-12-13 调整启动相关GPIO，ESO32添加GPIO9上拉电阻；STM32 BOOT0添加下拉电阻
2024-12-16 最小孔径增加到0.3mm，便于在大多数PCB工厂打样时降低成本
2024-12-16 大电流过孔扩大到0.4/0.8mm，调整过孔位置
2024-12-16 工程中修改为正确芯片型号QMC6308,ICM-42688-P，按数据手册更新供电滤波电容值
2024-12-16 添加第二个磁力计QMC7983
2024-12-18 添加build.py脚本，更新README.md和.gitignore文件
2024-12-18 按数据手册调整NS4168布线，电源GND改用单点连接，加粗电源和喇叭走线到0.6mm，中心焊盘连接GND增强散热性能
2024-12-18 调整电源走线，ESP32左侧添加3.3V覆铜
2024-12-18 修复一些ERC错误
2024-12-18 GND布线，检查回路完整性
2024-12-18 太阳能充电电流测量GND回路用NetTie分割为不同的网络，避免被覆铜覆盖
2024-12-20 添加FRAM储存器
2024-12-22 README添加待添加发电机电路记录，写下一些下一个版本的计划
2024-12-23 TP4056散热焊盘改用实心连接
2024-12-23 PCB边缘改半径2mm圆角，移动一些丝印避免与边缘过近
2024-12-23 发布v1.0
2024-12-27 fix: 根据PCB厂商EQ问题修复SGM2309的散热焊盘，添加到F.Mask层
2024-12-27 调整位号和文本丝印，恢复有用的被隐藏丝印，添加和优化一些文字
2025-01-24 修复R12封装错误，1210电容改为1206电阻
2025-03-21 doc: README中添加PCB设计缺陷描述

Notices in the files:
bicycle_board.kicad_pcb:
Copyright (C) 2024  Xu Ruijun
License under CERN-OHL-S v2
